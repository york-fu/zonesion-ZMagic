<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>template</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>serial-shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\apps\serial-shell\serial-shell.c</name>
      </file>
    </group>
    <group>
      <name>shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\apps\shell\shell.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>core</name>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\dev\leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\dev\nullradio.c</name>
      </file>
    </group>
    <group>
      <name>lib</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\aes-128.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\ccm-star.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\crc16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\gcr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\ifft.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\me.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\me_tabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\memb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\mmem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\petsciiconv.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\print-stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\ringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\sensors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\settings.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\core\lib\strncasecmp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\lib\trickle-timer.c</name>
      </file>
    </group>
    <group>
      <name>net</name>
      <group>
        <name>ip</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\dhcpc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\ip64-addr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\psock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\resolv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\simple-udp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\slipdev.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\tcp-socket.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\tcpip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\udp-socket.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-nameserver.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-packetqueue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-split.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uip-udp-packet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ip\uiplib.c</name>
        </file>
      </group>
      <group>
        <name>ipv4</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uaodv-rt.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uaodv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip-fw-drv.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip-fw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip-neighbor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip-over-mesh.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\core\net\ipv4\uip_arp.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\arg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\autostart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\compower.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\ctimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\dsc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\energest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\etimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\mt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\procinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\rtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\stimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\subprocess.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\core\sys\timer.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>cpu</name>
    <group>
      <name>arm</name>
      <group>
        <name>stm32f407</name>
        <group>
          <name>cmsis</name>
        </group>
        <group>
          <name>dcmi</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\DCMI\dcmi.c</name>
          </file>
        </group>
        <group>
          <name>fwlib</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\misc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_can.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_crc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_aes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_des.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_cryp_tdes.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dac.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dbgmcu.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dcmi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_dma2d.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_exti.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_flash_ramfunc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_fmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_fsmc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_gpio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash_md5.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_hash_sha1.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_i2c.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_iwdg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_ltdc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_pwr.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rcc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rng.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_rtc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_sai.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_sdio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_spi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_syscfg.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_tim.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_usart.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\FWLIB\src\stm32f4xx_wwdg.c</name>
          </file>
        </group>
        <group>
          <name>startup</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\startup\startup_stm32f40xx.s</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\startup\system_stm32f4xx.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\clock.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\debug.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\fsmc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\IIC3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\rtimer-arch.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\spi1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\spi2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\spi3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\uart1.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\uart2.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\uart3.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\uart4.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\usart6.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\cpu\arm\stm32f407\watchdog.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>zonesion</name>
    <group>
      <name>app</name>
      <group>
        <name>sensor</name>
        <file>
          <name>$PROJ_DIR$\..\..\app\sensor\sensor.c</name>
        </file>
      </group>
      <group>
        <name>src</name>
        <file>
          <name>$PROJ_DIR$\..\..\app\src\camera_app.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\app\src\led.c</name>
        </file>
      </group>
      <group>
        <name>view</name>
        <file>
          <name>$PROJ_DIR$\..\..\app\view\ui.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\app\view\ui_calendar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\app\view\ui_core.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\app\view\ui_RfInfo.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\app\view\ui_SysSet.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\app\autoapps.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\helloworld.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\sensor_process.c</name>
      </file>
    </group>
    <group>
      <name>commom</name>
      <group>
        <name>camera</name>
        <group>
          <name>OV2640</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\camera\OV2640\ov2640.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\camera\OV2640\sccb.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>dev</name>
        <group>
          <name>fml_lcd</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\dev\fml_lcd\fml_lcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\dev\fml_lcd\ili93xx.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\dev\fml_lcd\ST7789.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\BatteryVoltage.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\dm9051_stm.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\drive_key.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\drive_led.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\htu21d.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\onboard_sensors.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\relay.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\w25qxx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\dev\wk2xxx.c</name>
        </file>
      </group>
      <group>
        <name>ethernet</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\ethernet\ethernet.c</name>
        </file>
      </group>
      <group>
        <name>key</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\key\key.c</name>
        </file>
      </group>
      <group>
        <name>rf</name>
        <group>
          <name>ble</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\ble\ble-net.c</name>
          </file>
        </group>
        <group>
          <name>lora</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\lora\lora-net.c</name>
          </file>
        </group>
        <group>
          <name>lte</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\lte\lte-ec20.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\lte\lte-inf.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\lte\lte-tcp.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\lte\lte_config.c</name>
          </file>
        </group>
        <group>
          <name>wifi</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\wifi\wifi-net.c</name>
          </file>
        </group>
        <group>
          <name>zigbee</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\zigbee\zigbee-net.c</name>
          </file>
        </group>
        <group>
          <name>zxbee</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\rf\zxbee\zxbee.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\rf\hw.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\rf\rf_config.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\rf\rfUart.c</name>
        </file>
      </group>
      <group>
        <name>self_test</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\self_test\plus_test.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\common\self_test\test_ui.c</name>
        </file>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\app\contiki-conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\app\contiki-main.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\app\readme\readme.html</name>
  </file>
</project>


