# IAR project template.ewp, settings and files
configuration template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT; __FPU_USED; STM32F40_41xxx; _DLIB_FILE_DESCRIPTOR=1; USE_STDPERIPH_DRIVER; xWITH_IPV6; xWITH_II_802154; xWITH_RPL; DEV_TYPE=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\core; ..\..\..\..\..\core\net; ..\..\..\..\..\core\net\mac; ..\..\..\..\..\core\net\rpl; ..\..\..\..\..\core\net\rime; ..\..\..\common; ..\..\..\..\..\apps; ..\..\..\..\..\apps\shell; ..\..\..\..\..\apps\serial-shell; ..\..\..\common\cpu\arm\stm32f407\FWLIB\inc; ..\..\..\common\cpu\arm\stm32f407\startup; ..\..\..\common\cpu\arm\stm32f407\cmsis\Include; ..\..\..\common\cpu\arm\stm32f407; ..\..\dev; ..\..\app; ..\..\..\common\dev; ..\..\..\common\rf\zigbee; ..\..\app\image; ..\..\..\common\zxbee; ..\..\..\common\rf; ..\..\..\common\rf\ble; ..\..\..\common\rf\lora; ..\..\..\common\rf\wifi; ..\..\app\lcd; ..\..\app\sensor; ..\..\..\..\..\core\net\ip; ..\..\..\..\..\core\net\ipv4; ..\..\..\common\self_test; ..\..\..\common\ethernet; ..\..\..\common\net-drive; ..\..\..\common\key; ..\..\..\common\rf\zxbee; ..\..\..\common\rf\lte; ..\..\..\common\cpu\arm\stm32f407\DCMI; ..\..\..\common\camera\OV2640; ..\..\app\sensor; ..\..\app\src; ..\..\app\view
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../app/readme/: readme.html
  group app/serial-shell
    ../../../../../apps/serial-shell/: serial-shell.c
  group app/shell
    ../../../../../apps/shell/: shell.c
  group core/dev
    ../../../../../core/dev/: leds.c nullradio.c
  group core/lib
    ../../../../../core/lib/: aes-128.c assert.c ccm-star.c crc16.c gcr.c ifft.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c trickle-timer.c
    ../../../../core/lib/: strncasecmp.c
  group core/net/ip
    ../../../../../core/net/ip/: dhcpc.c ip64-addr.c psock.c resolv.c simple-udp.c slipdev.c tcp-socket.c tcpip.c udp-socket.c uip-debug.c uip-nameserver.c uip-packetqueue.c uip-split.c uip-udp-packet.c uiplib.c
  group core/net/ipv4
    ../../../../../core/net/ipv4/: uaodv-rt.c uaodv.c uip-fw-drv.c uip-fw.c uip-neighbor.c uip-over-mesh.c uip.c uip_arp.c
  group core/sys
    ../../../../../core/sys/: arg.c autostart.c compower.c ctimer.c dsc.h energest.c etimer.c mt.c process.c procinit.c rtimer.c stimer.c subprocess.h timer.c
  group cpu/arm/stm32f407
    ../../../common/cpu/arm/stm32f407/: adc.c clock.c debug.c exti.c fsmc.c IIC3.c rtimer-arch.c spi1.c spi2.c spi3.c uart1.c uart2.c uart3.c uart4.c usart6.c watchdog.c
  group cpu/arm/stm32f407/dcmi
    ../../../common/cpu/arm/stm32f407/DCMI/: dcmi.c
  group cpu/arm/stm32f407/fwlib
    ../../../common/cpu/arm/stm32f407/FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group cpu/arm/stm32f407/startup
    ../../../common/cpu/arm/stm32f407/startup/: startup_stm32f40xx.s system_stm32f4xx.c
  group zonesion
    ../../app/: contiki-conf.h contiki-main.c
  group zonesion/app
    ../../app/: autoapps.c helloworld.c sensor_process.c
  group zonesion/app/sensor
    ../../app/sensor/: sensor.c
  group zonesion/app/src
    ../../app/src/: camera_app.c led.c
  group zonesion/app/view
    ../../app/view/: ui.c ui_calendar.c ui_core.c ui_RfInfo.c ui_SysSet.c
  group zonesion/commom/camera/OV2640
    ../../../common/camera/OV2640/: ov2640.c sccb.c
  group zonesion/commom/dev
    ../../../common/dev/: BatteryVoltage.c dm9051_stm.c drive_key.c drive_led.c htu21d.c onboard_sensors.c relay.c w25qxx.c wk2xxx.c
  group zonesion/commom/dev/fml_lcd
    ../../../common/dev/fml_lcd/: fml_lcd.c ili93xx.c ST7789.c
  group zonesion/commom/ethernet
    ../../../common/ethernet/: ethernet.c
  group zonesion/commom/key
    ../../../common/key/: key.c
  group zonesion/commom/rf
    ../../../common/rf/: hw.c rf_config.h rfUart.c
  group zonesion/commom/rf/ble
    ../../../common/rf/ble/: ble-net.c
  group zonesion/commom/rf/lora
    ../../../common/rf/lora/: lora-net.c
  group zonesion/commom/rf/lte
    ../../../common/rf/lte/: lte-ec20.c lte-inf.c lte-tcp.c lte_config.c
  group zonesion/commom/rf/wifi
    ../../../common/rf/wifi/: wifi-net.c
  group zonesion/commom/rf/zigbee
    ../../../common/rf/zigbee/: zigbee-net.c
  group zonesion/commom/rf/zxbee
    ../../../common/rf/zxbee/: zxbee.c
  group zonesion/commom/self_test
    ../../../common/self_test/: plus_test.c test_ui.c
