<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>template</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>serial-shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\apps\serial-shell\serial-shell.c</name>
      </file>
    </group>
    <group>
      <name>shell</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\apps\shell\shell.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>core</name>
    <group>
      <name>dev</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\dev\leds.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\dev\nullradio.c</name>
      </file>
    </group>
    <group>
      <name>lib</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\crc16.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\gcr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\ifft.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\list.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\me.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\me_tabs.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\memb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\mmem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\print-stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\random.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\ringbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\settings.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\lib\trickle-timer.c</name>
      </file>
    </group>
    <group>
      <name>sys</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\arg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\autostart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\compower.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\ctimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\energest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\etimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\procinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\rtimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\stimer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\..\core\sys\timer.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>zonesion</name>
    <group>
      <name>app</name>
      <group>
        <name>App</name>
        <file>
          <name>$PROJ_DIR$\..\..\app\App\src\App.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\app\App\src\ErrorDLG.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\app\App\src\View.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\app\autoapps.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\app\helloworld.c</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <group>
        <name>APL</name>
        <group>
          <name>apl_cpu</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\APL\apl_cpu\apl_cpu.c</name>
          </file>
        </group>
        <group>
          <name>apl_debug</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\APL\apl_debug\debug.c</name>
          </file>
        </group>
        <group>
          <name>apl_font</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\APL\apl_font\GUIFont_Port.c</name>
          </file>
        </group>
        <group>
          <name>apl_key</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\APL\apl_key\apl_key.c</name>
          </file>
        </group>
        <group>
          <name>apl_led</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\APL\apl_led\LedProcess.c</name>
          </file>
        </group>
        <group>
          <name>FATFS</name>
          <group>
            <name>option</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\common\APL\FATFS\option\cc936.c</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\APL\FATFS\diskio.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\APL\FATFS\ff.c</name>
          </file>
        </group>
        <group>
          <name>STemWin</name>
          <group>
            <name>config</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\common\APL\STemWinLibrary532\OS\GUI_X.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\common\APL\STemWinLibrary532\Config\GUI_X_Touch_Analog.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\common\APL\STemWinLibrary532\Config\GUIConf.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\common\APL\STemWinLibrary532\Config\GUIDRV_Template.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\common\APL\STemWinLibrary532\Config\LCDConf_FlexColor_Template.c</name>
            </file>
          </group>
          <group>
            <name>lib</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\common\APL\STemWinLibrary532\Lib\STemWin532_CM4_IAR.a</name>
            </file>
          </group>
        </group>
      </group>
      <group>
        <name>FML</name>
        <group>
          <name>fml_key</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\FML\fml_key\fml_key.c</name>
          </file>
        </group>
        <group>
          <name>fml_lcd</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\FML\fml_lcd\fml_lcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\FML\fml_lcd\ft6x36.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\FML\fml_lcd\ST7789.c</name>
          </file>
        </group>
        <group>
          <name>fml_led</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\FML\fml_led\fml_led.c</name>
          </file>
        </group>
        <group>
          <name>fml_sd</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\FML\fml_sd\sd_spi.c</name>
          </file>
        </group>
        <group>
          <name>fml_SpiFlash</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\FML\fml_w25qxx\w25qxx.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>HAL</name>
        <group>
          <name>stm32f407</name>
          <group>
            <name>clock</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\clock\clock.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\clock\delay.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\clock\rtimer-arch.c</name>
            </file>
          </group>
          <group>
            <name>cmsis</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\cmsis\Lib\ARM\arm_cortexM4lf_math.lib</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\cmsis\Lib\ARM\iar_cortexM4lf_math.a</name>
            </file>
          </group>
          <group>
            <name>fwlib</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\misc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_adc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_can.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_crc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_cryp.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_cryp_aes.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_cryp_des.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_cryp_tdes.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_dac.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_dbgmcu.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_dcmi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_dma.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_dma2d.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_exti.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_flash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_flash_ramfunc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_fsmc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_gpio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_hash.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_hash_md5.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_hash_sha1.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_i2c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_iwdg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_ltdc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_pwr.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_rcc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_rng.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_rtc.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_sai.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_sdio.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_spi.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_syscfg.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_tim.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_usart.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\src\stm32f4xx_wwdg.c</name>
            </file>
          </group>
          <group>
            <name>starup</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\startup\startup_stm32f40xx.s</name>
            </file>
          </group>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\common\HAL\stm32f407\FWLIB\system_stm32f4xx.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>MPL</name>
        <group>
          <name>mpl_exti</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_exti\exti.c</name>
          </file>
        </group>
        <group>
          <name>mpl_fsmc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_fsmc\fsmc.c</name>
          </file>
        </group>
        <group>
          <name>mpl_iic</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_iic\soft_iic.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_iic\soft_iic1.c</name>
          </file>
        </group>
        <group>
          <name>mpl_spi</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_spi\spi1.c</name>
          </file>
        </group>
        <group>
          <name>mpl_uart</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_uart\uart1.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_uart\uart2.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_uart\uart4.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\common\MPL\mpl_uart\usart6.c</name>
          </file>
        </group>
      </group>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\app\contiki-conf.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\app\contiki-main.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\..\..\app\readme\readme.html</name>
  </file>
</project>


