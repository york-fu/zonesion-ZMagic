<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$\GreenHouse-3.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
    </batchDefinition>
  </batchBuild>
</workspace>
