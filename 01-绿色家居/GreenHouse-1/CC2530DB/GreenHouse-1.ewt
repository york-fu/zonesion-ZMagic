<?xml version="1.0" encoding="iso-8859-1"?>
<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>GreenHouse-1</name>
    <toolchain>
      <name>8051</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>App</name>
    <file>
      <name>$PROJ_DIR$\..\Source\BH1750.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\fan.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\htu21d.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\iic.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\MP-503.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\readme.txt</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\relay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\sensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\stepmotor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Source\UserAt.c</name>
    </file>
  </group>
  <group>
    <name>COMMON</name>
    <file>
      <name>$PROJ_DIR$\..\..\common\AppCommon.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\at-uart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\at.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\device_find.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sapi\sapi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sapi\sapi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\SimpleApp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\zxbee-inf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\zxbee-sys-command.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\common\zxbee.c</name>
    </file>
  </group>
  <group>
    <name>HAL</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\common\hal_assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\common\hal_drivers.c</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_board.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_ccm.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_defs.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_drivers.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_lcd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_led.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_sleep.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_timer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\include\hal_uart.h</name>
      </file>
    </group>
    <group>
      <name>Target</name>
      <group>
        <name>CC2530EB</name>
        <group>
          <name>Config</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_board_cfg.h</name>
          </file>
        </group>
        <group>
          <name>Drivers</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_adc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_dma.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_flash.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_key.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_lcd.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_led.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_sleep.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_startup.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_timer.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_uart.c</name>
          </file>
        </group>
        <group>
          <name>Includes</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_aes.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_dma.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_mcu.h</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\Components\hal\target\CC2530EB\hal_types.h</name>
          </file>
        </group>
      </group>
    </group>
  </group>
  <group>
    <name>MAC</name>
    <group>
      <name>High Level</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_cfg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_high_level.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_pib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_pib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\high_level\mac_spec.h</name>
      </file>
    </group>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\include\mac_api.h</name>
      </file>
    </group>
    <group>
      <name>Low Level</name>
      <group>
        <name>Common</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_assert.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_autopend.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_autopend.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_backoff_timer.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_backoff_timer.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_low_level.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_low_level.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_radio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_radio.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_rx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_rx.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_rx_onoff.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_rx_onoff.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_sleep.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_sleep.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_tx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\mac_tx.h</name>
        </file>
      </group>
      <group>
        <name>System</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_csp_tx.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_csp_tx.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_mcu.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_mcu.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_mem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_mem.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_radio_defs.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_radio_defs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\Components\mac\low_level\srf04\single_chip\mac_rffrontend.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>MT</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\DebugTrace.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\DebugTrace.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_AF.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_AF.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_APP.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_APP.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_DEBUG.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_DEBUG.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_NWK.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_NWK.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_RPC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_SAPI.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_SAPI.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_SYS.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_SYS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_TASK.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_TASK.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_UART.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\mt_uart.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_UTIL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_UTIL.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_VERSION.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_VERSION.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_ZDO.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\mt\MT_ZDO.h</name>
    </file>
  </group>
  <group>
    <name>NWK</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\AddrMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\APS.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_frag.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_groups.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\aps_util.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\APSMEDE.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\AssocList.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\BindingTable.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\NLMEDE.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_bufs.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_globals.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_globals.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\nwk_util.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\reflecttrack.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\rtg.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\stub_aps.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\nwk\stub_aps.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sys\ZGlobals.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sys\ZGlobals.h</name>
    </file>
  </group>
  <group>
    <name>OSAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\comdef.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_Clock.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Clock.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\mcu\cc2530\OSAL_Math.s51</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_Memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Memory.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\mcu\cc2530\OSAL_Nv.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Nv.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_PwrMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_PwrMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Tasks.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\common\OSAL_Timers.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\OSAL_Timers.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\osal\include\ZComDef.h</name>
    </file>
  </group>
  <group>
    <name>Profile</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\af\AF.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\af\AF.h</name>
    </file>
  </group>
  <group>
    <name>Security</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sec\ssp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\sec\ssp_hash.h</name>
    </file>
  </group>
  <group>
    <name>Services</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\services\saddr\saddr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\services\saddr\saddr.h</name>
    </file>
  </group>
  <group>
    <name>Tools</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2530DB\f8w2530.xcl</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2530DB\f8wConfig.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2530DB\f8wCoord.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2530DB\f8wEndev.cfg</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Tools\CC2530DB\f8wRouter.cfg</name>
    </file>
  </group>
  <group>
    <name>ZDO</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDApp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDApp.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDConfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDNwkMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDNwkMgr.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDObject.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDObject.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDProfile.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDProfile.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDSecMgr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\stack\zdo\ZDSecMgr.h</name>
    </file>
  </group>
  <group>
    <name>ZMac</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\ZMAC.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac_cb.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\Components\zmac\f8w\zmac_internal.h</name>
    </file>
  </group>
  <group>
    <name>ZMain</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\ZMain\TI2530DB\chipcon_cstartup.s51</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\ZMain\TI2530DB\OnBoard.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\ZMain\TI2530DB\OnBoard.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\ZMain\TI2530DB\ZMain.c</name>
    </file>
  </group>
</project>
